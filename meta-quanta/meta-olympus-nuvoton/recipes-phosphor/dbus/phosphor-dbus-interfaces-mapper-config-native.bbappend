PHOSPHOR_MAPPER_SERVICE:append = " com.intel.crashdump"
PHOSPHOR_MAPPER_INTERFACE:append = " com.intel.crashdump"
