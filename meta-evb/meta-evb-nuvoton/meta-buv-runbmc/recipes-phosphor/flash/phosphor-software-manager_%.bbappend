PACKAGECONFIG:buv-runbmc += "verify_signaturei flash_bios"
