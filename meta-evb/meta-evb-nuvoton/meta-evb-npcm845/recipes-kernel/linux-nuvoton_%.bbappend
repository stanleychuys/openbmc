FILESEXTRAPATHS_prepend_evb-npcm845 := "${THISDIR}/linux-nuvoton:"

SRC_URI_append_evb-npcm845 = " \
  file://evb-npcm845.cfg \
  "

